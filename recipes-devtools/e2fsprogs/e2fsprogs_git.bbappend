FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://xattr_rootdir.patch"
