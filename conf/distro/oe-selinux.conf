## conf/distro/oe-selinux.conf
```bitbake
DISTRO = "oe-selinux"
DISTROOVERRIDES .= ":selinux"

PREFERRED_VERSION_linux-yocto = "3.14%"

DISTRO_FEATURES_append = " acl xattr pam selinux"
```
